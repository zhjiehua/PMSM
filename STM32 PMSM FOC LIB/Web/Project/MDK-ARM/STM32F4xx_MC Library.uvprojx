# Keil uVision project STM32F4xx_MC Library.uvprojx, settings and files
target STM32F4xx Single Drive (ARM-ADS)
  device: STM32F405ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MC_Library_STM32F4xx_single_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, MC_LIBRARY_SINGLE, ARM_MATH_CM4
  c include: ..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Project;"..\..\MCLibrary";"..\..\MCLibrary\inc";"..\..\MCLibrary\interface";"..\..\MCLibrary\interface\common"
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MCLibrary_interface_common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h RampExtMngrClass.h
  group MCLibrary_interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h MTPACtrlClass.h OpenLoopClass.h OneTouchTuningClass.h SelfComCtrlClass.h GAP_GateDriverCtrlClass.h GateDriverCtrlClass.h
  group MCLibrary_private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h DigitalOutputPrivate.h EncAlignCtrlPrivate.h ENCODER_SpeednPosFdbkPrivate.h HALL_SpeednPosFdbkPrivate.h ICS_HD2_PWMnCurrFdbkPrivate.h ICS_LM1_PWMnCurrFdbkPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h NTC_TemperatureSensorPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h R1_HD2_PWMnCurrFdbkPrivate.h R1_LM1_PWMnCurrFdbkPrivate.h R1_VL1_PWMnCurrFdbkPrivate.h R3_HD2_PWMnCurrFdbkPrivate.h R3_LM1_PWMnCurrFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h Rdivider_BusVoltageSensorPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h CircleLimitationPrivate.h OpenLoopPrivate.h HiFreqInj_FPU_SpeednPosFdbkPrivate.h GAP_GateDriverCtrlPrivate.h GateDriverCtrlPrivate.h
  group MCLibrary_src
    ../../MCLibrary/src/: BusVoltageSensorClass.c EncAlignCtrlClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c NTC_TemperatureSensorClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c Rdivider_BusVoltageSensorClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c R3_F4XX_PWMnCurrFdbkClass.c DigitalOutputClass_F4XX.c ENC_F4xx_SpeednPosFdbkClass.c HALL_F4xx_SpeednPosFdbkClass.c ICS_F4XX_PWMnCurrFdbkClass.c InrushCurrentLimiterClass.c R1_F4XX_PWMnCurrFdbkClass.c RampExtMngrClass.c RampMngrClass.c CircleLimitationClass.c OpenLoopClass.c HiFreqInj_FPU_SpeednPosFdbkClass.c GAP_F4xx_GateDriverCtrlClass.c GAP_GateDriverCtrlClass.c GateDriverCtrlClass.c
  group MCLibrary_conf
    ../../MCLibrary/: stm32f40x_MisraCompliance.h MCLibraryConf.h
  group MCLibrary_lib_single
    ./MC_Library_Compiled/RVMDK_MCLIB_OBJS_SINGLE/: MC_Library_ProtectedSources_single_drive_CM4_MKD.lib
  group MCLibrary_lib_dual
    ./MC_Library_Compiled/RVMDK_MCLIB_OBJS_DUAL/: MC_Library_ProtectedSources_dual_drive_CM4_MKD.lib
target STM32F4xx Dual Drive (ARM-ADS)
  device: STM32F405ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: MC_Library_STM32F4xx_dual_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, MC_LIBRARY_DUAL, ARM_MATH_CM4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
