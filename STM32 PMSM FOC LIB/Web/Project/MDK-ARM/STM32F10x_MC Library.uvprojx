# Keil uVision project STM32F10x_MC Library.uvprojx, settings and files
target STM32F10x Single Drive (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MC_Library_STM32F10x_single_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, MC_LIBRARY_SINGLE
  c include: ..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Project;..\..\MCLibrary;..\..\MCLibrary\inc;..\..\MCLibrary\interface;..\..\MCLibrary\interface\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MCLibrary_interface_common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h RampExtMngrClass.h
  group MCLibrary_interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h MTPACtrlClass.h OpenLoopClass.h GAP_GateDriverCtrlClass.h GateDriverCtrlClass.h
  group MCLibrary_private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h DigitalOutputPrivate.h EncAlignCtrlPrivate.h ENCODER_SpeednPosFdbkPrivate.h HALL_SpeednPosFdbkPrivate.h ICS_HD2_PWMnCurrFdbkPrivate.h ICS_LM1_PWMnCurrFdbkPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h NTC_TemperatureSensorPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h R1_HD2_PWMnCurrFdbkPrivate.h R1_LM1_PWMnCurrFdbkPrivate.h R1_VL1_PWMnCurrFdbkPrivate.h R3_HD2_PWMnCurrFdbkPrivate.h R3_LM1_PWMnCurrFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h Rdivider_BusVoltageSensorPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h CircleLimitationPrivate.h OpenLoopPrivate.h
    ../../MCLibrary/interface/: GAP_GateDriverCtrlClass.h GateDriverCtrlClass.h
  group MCLibrary_src
    ../../MCLibrary/src/: BusVoltageSensorClass.c DigitalOutputClass.c EncAlignCtrlClass.c ENCODER_SpeednPosFdbkClass.c HALL_SpeednPosFdbkClass.c ICS_HD2_PWMnCurrFdbkClass.c ICS_LM1_PWMnCurrFdbkClass.c InrushCurrentLimiterClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c NTC_TemperatureSensorClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c R1_HD2_PWMnCurrFdbkClass.c R1_LM1_PWMnCurrFdbkClass.c R1_VL1_PWMnCurrFdbkClass.c R3_HD2_PWMnCurrFdbkClass.c R3_LM1_PWMnCurrFdbkClass.c RampExtMngrClass.c RampMngrClass.c Rdivider_BusVoltageSensorClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c CircleLimitationClass.c OpenLoopClass.c GAP_F1xx_GateDriverCtrlClass.c GAP_GateDriverCtrlClass.c GateDriverCtrlClass.c
  group MCLibrary_conf
    ../../MCLibrary/: stm32f10x_MisraCompliance.h MCLibraryConf.h
  group MCLibrary_lib_single
    ./MC_Library_Compiled/RVMDK_MCLIB_OBJS_SINGLE/: MC_Library_ProtectedSources_single_drive_MKD.lib
  group MCLibrary_lib_dual
    ./MC_Library_Compiled/RVMDK_MCLIB_OBJS_DUAL/: MC_Library_ProtectedSources_dual_drive_MKD.lib
target STM32F10x Dual Drive (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MC_Library_STM32F10x_dual_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, MC_LIBRARY_DUAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
