# Keil uVision project STM32F4xx_UserProject.uvprojx, settings and files
target STM324xG-EVAL (ARM-ADS)
  device: STM32F405ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: STM324xG-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, USE_STM324xG_EVAL, ARM_MATH_CM4
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MCLibrary_interface_common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group MCLibrary_interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_F4XX_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_DD_PWMnCurrFdbkClass.h R1_F4XX_PWMnCurrFdbkClass.h R3_DD_PWMnCurrFdbkClass.h R3_F4XX_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h MTPACtrlClass.h OpenLoopClass.h
  group MCLibrary_lib
    ../MC_Library_Compiled/STM32F4xx_SD/: MC_Library_STM32F4xx_single_drive.lib
    ../MC_Library_Compiled/STM32F4xx_DD/: MC_Library_STM32F4xx_dual_drive.lib
  group MCApplication_interface
    ../../../MCApplication/interface/: MCInterfaceClass.h MCTasks.h MCTuningClass.h MC.h
  group MCApplication_private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group MCApplication_src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group CMSIS
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df2T_f32.c
  group StdPeriph_Driver_F4XX
    ../../../../Common/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c
  group STM32_EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_lcd.c stm324xg_eval.c stm324xg_eval_ioe.c
    ../../../../Common/Libraries/STM32_EVAL/STM32F4XX_DUAL/: STM32F4xx_dual_lcd.c STM32F4xx_dual.c
    ../../../../Common/Libraries/STM32_EVAL/STM32446E_EVAL/: stm32446e_eval.c stm32446e_eval_ioe.c stm32446e_eval_lcd.c
  group RVMDK
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group UILibrary_interface
    ../../../UILibrary/interface/: DAC_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h LCDVintage_UserInterfaceClass.h UnidirectionalFastCom_UserInterfaceClass.h
  group UILibrary_private
    ../../../UILibrary/inc/: DAC_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCD_Interface.h LCDManager_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h UnidirectionalFastCom_UserInterfacePrivate.h
  group UILibrary_src
    ../../../UILibrary/src/: FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UserInterfaceClass.c USART_F4XX_PhysicalLayerCommunication_Class.c DAC_F4XX_UserInterfaceClass.c LCDVintage_UserInterfaceClass.c UnidirectionalFastCom_F4XX_UserInterfaceClass.c
  group Project
    ../../: UITask.c main.c Timebase.c stm32f4xx_it.c GAPApplication.c
    ../../../SystemDriveParams/: stm32f4xx_MC_it.c
  group System & Drive Params
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Control stage parameters.h Drive parameters motor 2.h Drive parameters.h Parameters conversion motor 2.h Parameters conversion.h Parameters conversion_F4xx motor 2.h Parameters conversion_F4xx.h PMSM motor 2 parameters.h PMSM motor parameters.h Power stage parameters motor 2.h Power stage parameters.h SystemNDriveParams.h
  group Doc
    ./: readme.txt
target STEVAL-IHM039V1_DUALDRIVE (ARM-ADS)
  device: STM32F405ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: STEVAL-IHM039V1_DUALDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, USE_STM32F4XX_DUAL, ARM_MATH_CM4
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM32F4XX_DUAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STEVAL-IHM039V1_SINGLEDRIVE (ARM-ADS)
  device: STM32F405ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: STEVAL-IHM039V1_SINGLEDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32446E-EVAL (ARM-ADS)
  device: STM32F446MCYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F446xx, USE_STM32446E_EVAL, ARM_MATH_CM4
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM32446E_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM32F446_DUAL_DRIVE (ARM-ADS)
  device: STM32F446MCYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: STEVAL-IHM039V1_DUALDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F446xx, ARM_MATH_CM4
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;..\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
