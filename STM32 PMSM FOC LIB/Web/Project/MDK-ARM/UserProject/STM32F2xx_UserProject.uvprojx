# Keil uVision project STM32F2xx_UserProject.uvprojx, settings and files
target STM322xG-EVAL (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F2XX, USE_STM322xG_EVAL, ARM_MATH_CM3
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F2xx\Include;..\..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MCLibrary_interface_common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group MCLibrary_interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_F2XX_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_DD_PWMnCurrFdbkClass.h R1_F2XX_PWMnCurrFdbkClass.h R3_DD_PWMnCurrFdbkClass.h R3_F2XX_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h MTPACtrlClass.h OpenLoopClass.h
  group MCLibrary_lib
    ../MC_Library_Compiled/STM32F2xx_SD/: MC_Library_STM32F2xx_single_drive.lib
    ../MC_Library_Compiled/STM32F2xx_DD/: MC_Library_STM32F2xx_dual_drive.lib
  group MCApplication_interface
    ../../../MCApplication/interface/: MCInterfaceClass.h MCTasks.h MCTuningClass.h MC.h
  group MCApplication_private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group MCApplication_src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group CMSIS
    ../../../../Common/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group StdPeriph_Driver_F2XX
    ../../../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_wwdg.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c misc.c
  group STM32_EVAL
    ../../../../Common/Libraries/STM32_EVAL/: stm32_eval.c
    ../../../../Common/Libraries/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c stm322xg_eval_fsmc_onenand.c stm322xg_eval_fsmc_psram.c stm322xg_eval_ioe.c
    ../../../../Common/Libraries/STM32_EVAL/STM32F2XX_DUAL/: STM32F2xx_dual.c STM32F2xx_dual_lcd.c
  group RVMDK
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group UILibrary_interface
    ../../../UILibrary/interface/: DAC_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h LCDVintage_UserInterfaceClass.h UnidirectionalFastCom_UserInterfaceClass.h
  group UILibrary_private
    ../../../UILibrary/inc/: DAC_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCD_Interface.h LCDManager_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h UnidirectionalFastCom_UserInterfacePrivate.h
  group UILibrary_src
    ../../../UILibrary/src/: FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UserInterfaceClass.c USART_F2XX_PhysicalLayerCommunication_Class.c DAC_F2XX_UserInterfaceClass.c LCDVintage_UserInterfaceClass.c
  group Project
    ../../: UITask.c main.c Timebase.c stm32f2xx_it.c
    ../../../SystemDriveParams/: stm32f2xx_MC_it.c
  group System & Drive Params
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Control stage parameters.h Drive parameters motor 2.h Drive parameters.h Parameters conversion motor 2.h Parameters conversion.h Parameters conversion_F2xx motor 2.h Parameters conversion_F2xx.h PMSM motor 2 parameters.h PMSM motor parameters.h Power stage parameters motor 2.h Power stage parameters.h SystemNDriveParams.h
  group Doc
    ./: readme.txt
target STM32F2xx_dual (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F2xx_dual
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F2XX, USE_STM32F2XX_DUAL, ARM_MATH_CM3
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F2xx\Include;..\..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM32F2xx_dual;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
