# Keil uVision project STM32F0xx_UserProject.uvprojx, settings and files
target STM320518-EVAL (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM320518-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,USE_STM320518_EVAL,ARM_MATH_CM0
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F0xx\Include;..\..\..\..\Common\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\..\Common\Libraries\STM32_EVAL\STM320518_EVAL;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\SystemDriveParams;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MCLibrary_interface_common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group MCLibrary_interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_F0XX_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h MTPACtrlClass.h OpenLoopClass.h
  group MCLibrary_lib
    ../MC_Library_Compiled/STM32F0xx_SD/: MC_Library_STM32F0xx_single_drive.lib
  group MCApplication_interface
    ../../../MCApplication/interface/: MCInterfaceClass.h MCTasks.h MCTuningClass.h MC.h
  group MCApplication_private
    ../../../MCApplication/inc/: MCInterfacePrivate.h MCInterfaceClassPrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group MCApplication_src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group Std project template
    ./../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./../../../../Common/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./../../../../Common/Libraries/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_lcd.c
  group UILibrary_interface
    ../../../UILibrary/interface/: DAC_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h LCDVintage_UserInterfaceClass.h UnidirectionalFastCom_UserInterfaceClass.h
  group UILibrary_private
    ../../../UILibrary/inc/: DAC_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCD_Interface.h LCDManager_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h UnidirectionalFastCom_UserInterfacePrivate.h
  group UILibrary_src
    ../../../UILibrary/src/: DAC_F0XX_UserInterfaceClass.c DAC_F072_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c USART_F0XX_PhysicalLayerCommunication_Class.c UserInterfaceClass.c LCDVintage_UserInterfaceClass.c UnidirectionalFastCom_F0XX_UserInterfaceClass.c
  group Project
    ./../../: main.c stm32f0xx_it.c Timebase.c UITask.c
    ../../../SystemDriveParams/: stm32f0xx_MC_it.c
  group System & Drive Params
    ../../../SystemDriveParams/: Control stage parameters.h Drive parameters.h Parameters conversion.h Parameters conversion_F0xx.h PMSM motor parameters.h Power stage parameters.h SystemNDriveParams.h
  group Doc
    ./: readme.txt
target STM32072B-EVAL (ARM-ADS)
  device: STM32F072VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM320518-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: as above
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\\CMSIS_2_x\Device\ST\STM32F0xx\Include;..\..\..\..\Common\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\..\Common\Libraries\STM32_EVAL\STM320518_EVAL;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\SystemDriveParams;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM32F030 (ARM-ADS)
  device: STM32F030RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM320518-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target STM32SPIN (ARM-ADS)
  device: STM32F031K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM320518-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
