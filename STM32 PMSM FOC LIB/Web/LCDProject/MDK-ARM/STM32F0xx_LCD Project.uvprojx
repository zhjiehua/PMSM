# Keil uVision project STM32F0xx_LCD Project.uvprojx, settings and files
target STM320518-EVAL (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM320518-EVAL +hex
  AfterMake: .\STM320518-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,USE_STM320518_EVAL
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F0xx\Include;.\..\..\..\Common\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM320518_EVAL;.\..\..\MCLibrary\interface\common;.\..\..\MCApplication\interface;.\..\..\SystemDriveParams;.\..\..\UILibrary\inc;.\..\..\UILibrary\interface;.\..\..\UILibrary\STMFC
  memory RVCT4: ROM 0x8007e00 size 0x8200
  memory RVCT9: RAM 0x20001000 size 0xff0
  memory RVCT10: RAM 0x20001ff0 size 0x10
  scatter file: .\sct\STM32F0518.sct
  group LCD Interface
    ./../: images.c images.h
    ./../../UILibrary/src/: LCD_Interface.cpp
    ./../../UILibrary/inc/: LCD_Interface.h
  group Std project template
    ./../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./startup/arm/: startup_stm32f0xx.s
    ./../../../Common/Libraries/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
    ./../../../Common/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./../../../Common/Libraries/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_lcd.c
    ../../../Common/Libraries/STM32_EVAL/STM32072B_EVAL/: stm32072b_eval.c stm32072b_eval_lcd.c
  group STMFC
    ./../../UILibrary/STMFC/: CSTMInput.cpp CSTMInput.h CSTMLCDMngr.cpp CSTMLCDMngr.h CSTMWin.cpp CSTMWin.h CSTMWinCtrls.cpp CSTMWinCtrls.h CSTMWinForm.cpp CSTMWinForm.h font2.c font2.h STMFC.h
  group UI Library
    ./../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group user
    ./../: main.c
    ./: LCD_MDK_asm.s
target STM32072B-EVAL (ARM-ADS)
  device: STM32F072VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32072B-EVAL +hex
  AfterMake: .\STM32072B-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,USE_STM32072B_EVAL
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F0xx\Include;.\..\..\..\Common\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM32072B_EVAL;.\..\..\MCLibrary\interface\common;.\..\..\MCApplication\interface;.\..\..\SystemDriveParams;.\..\..\UILibrary\inc;.\..\..\UILibrary\interface;.\..\..\UILibrary\STMFC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\sct\STM32F072B.sct
