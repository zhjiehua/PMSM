# Keil uVision project STM32F3xx_LCD Project.uvprojx, settings and files
target STM32303C-EVAL-SINGLEDRIVE (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32303C-EVAL_SINGLEDRIVE +hex
  AfterMake: .\STM32303C-EVAL_SINGLEDRIVE.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,USE_STM32303C_EVAL,STM32F303X
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include;.\..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM32303C_EVAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC";.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include
  memory RVCT4: ROM 0x8030000 size 0x10000
  memory RVCT9: RAM 0x20006000 size 0x1ff0
  memory RVCT10: RAM 0x20007ff0 size 0x10
  scatter file: .\sct\STM32303C-EVAL.sct
  group LCD Interface
    ./../: images.c images.h
    ./../../UILibrary/src/: LCD_Interface.cpp
    ./../../UILibrary/inc/: LCD_Interface.h
  group Std project template
    ../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
    ./startup/arm/: startup_stm32f30x.s
    ../../../Common/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
    ../../../Common/Libraries/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval_lcd.c stm32303c_eval.c
  group STMFC
    ./../../UILibrary/STMFC/: CSTMInput.cpp CSTMInput.h CSTMLCDMngr.cpp CSTMLCDMngr.h CSTMWin.cpp CSTMWin.h CSTMWinCtrls.cpp CSTMWinCtrls.h CSTMWinForm.cpp CSTMWinForm.h font2.c font2.h STMFC.h
  group UILibrary
    ./../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group user
    ./../: main.c
    ./: LCD_MDK_asm.s
target STM32303C-EVAL-DUALDRIVE (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303C-EVAL_DUALDRIVE +hex
  AfterMake: .\STM32303C-EVAL_DUALDRIVE.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,USE_STM32303C_EVAL,STM32F303X
  c include: as above
  memory RVCT4: ROM 0x8030000 size 0x10000
  memory RVCT9: RAM 0x20006000 size 0x1ff0
  memory RVCT10: RAM 0x20007ff0 size 0x10
  scatter file: .\sct\STM32303C-EVAL.sct
