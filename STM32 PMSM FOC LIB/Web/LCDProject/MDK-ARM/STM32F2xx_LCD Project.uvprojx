# Keil uVision project STM32F2xx_LCD Project.uvprojx, settings and files
target STM322xG-EVAL (ARM-ADS)
  device: STM32F217ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL +hex
  AfterMake: .\STM322xG-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F2xx\Include;.\..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM322xG_EVAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC";.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include
  memory RVCT4: ROM 0x80f0000 size 0x10000
  memory RVCT9: RAM 0x2001e000 size 0x1ff0
  memory RVCT10: RAM 0x2001fff0 size 0x10
  scatter file: .\sct\STM32F2xx.sct
  group LCD Interface
    ./../: images.c
    ./../../UILibrary/src/: LCD_Interface.cpp
  group Std project template
    ./startup/arm/: startup_stm32f2xx.s
    ./../../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ./../../../Common/Libraries/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/STM32F2XX_DUAL/: STM32F2xx_dual.c STM32F2xx_dual_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/: stm32_eval.c
    ../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ../../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
  group STMFC
    ./../../UILibrary/STMFC/: CSTMInput.cpp CSTMLCDMngr.cpp CSTMWin.cpp CSTMWinCtrls.cpp CSTMWinForm.cpp font2.c
  group UILibrary
    ./../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group user
    ./../: main.c
    ./: LCD_MDK_asm.s
target STM32F2xx_dual (ARM-ADS)
  device: STM32F217IE STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F2xx_dual +hex
  AfterMake: .\STM32F2xx_dual.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM32F2XX_DUAL,
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F2xx\Include;.\..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM32F2XX_DUAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC";.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include
  memory RVCT4: ROM 0x80f0000 size 0x10000
  memory RVCT9: RAM 0x2001e000 size 0x1ff0
  memory RVCT10: RAM 0x2001fff0 size 0x10
  scatter file: .\sct\STM32F2xx.sct
