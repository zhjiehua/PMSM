# Keil uVision project STM32F10x_LCD Project.uvprojx, settings and files
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL +hex
  AfterMake: .\STM3210E-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL,
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport;.\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM3210E_EVAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC"
  memory RVCT4: ROM 0x8070000 size 0x10000
  memory RVCT9: RAM 0x2000e000 size 0x1ff0
  memory RVCT10: RAM 0x2000fff0 size 0x10
  scatter file: .\sct\STM32F103_HD.sct
  group LCD Interface
    ./../: images.c images.h
    ./../../UILibrary/src/: LCD_Interface.cpp
    ./../../UILibrary/inc/: LCD_Interface.h
  group Std project template
    ./../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s
    ./../../../Common/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./../../../Common/Libraries/STM32_EVAL/STEVAL-IHM022V1/: steval-ihm022v1_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c stm3210c_eval_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/: stm32_eval.c
    ../../../Common/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group STMFC
    ./../../UILibrary/STMFC/: CSTMInput.cpp CSTMInput.h CSTMLCDMngr.cpp CSTMLCDMngr.h CSTMWin.cpp CSTMWin.h CSTMWinCtrls.cpp CSTMWinCtrls.h CSTMWinForm.cpp CSTMWinForm.h font2.c font2.h STMFC.h
  group UI Library
    ./../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group user
    ./../: main.c
    ./: LCD_MDK_asm.s
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL +hex
  AfterMake: .\STM3210B-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_STM3210B_EVAL,
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM3210B_EVAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC";.\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20003000 size 0x1ff0
  memory RVCT10: RAM 0x20004ff0 size 0x10
  scatter file: .\sct\STM32F103_MD.sct
target STM32100B-EVAL (ARM-ADS)
  device: STM32F100CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100B-EVAL +hex
  AfterMake: .\STM32100B-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD_VL,USE_STM32100B_EVAL,
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM32100B_EVAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC";.\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8013800 size 0xc800
  memory RVCT9: RAM 0x20001000 size 0xff0
  memory RVCT10: RAM 0x20001ff0 size 0x10
  scatter file: .\sct\STM32F100.sct
target STEVAL-IHM022V1_SINGLEDRIVE (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STEVAL-IHM022V1_SINGLEDRIVE +hex
  AfterMake: .\STEVAL-IHM022V1_SINGLEDRIVE.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STEVAL_IHM022V1,
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STEVAL-IHM022V1;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC";.\..\..\..\Common\Libraries\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\sct\STM32F103_HD.sct
target STEVAL-IHM022V1_DUALDRIVE (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: STEVAL-IHM022V1_DUALDRIVE +hex
  AfterMake: .\STEVAL-IHM022V1_DUALDRIVE.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STEVAL_IHM022V1,
  c include: as above
  memory RVCT4: ROM 0x8070000 size 0x10000
  memory RVCT9: RAM 0x2000e000 size 0x1ff0
  memory RVCT10: RAM 0x2000fff0 size 0x10
  scatter file: .\sct\STM32F103_HD.sct
