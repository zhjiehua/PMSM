# Keil uVision project STM32F4xx_LCD Project.uvprojx, settings and files
target STM32446E-EVAL (ARM-ADS)
  device: STM32F446MCYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32446E-EVAL +hex
  AfterMake: .\STM32446E-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F446xx,USE_STM32446E_EVAL
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;.\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM32446E_EVAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC"
  memory RVCT4: ROM 0x8070000 size 0x10000
  memory RVCT9: RAM 0x2001e000 size 0x1ff0
  memory RVCT10: RAM 0x2001fff0 size 0x10
  scatter file: .\sct\STM32F446.sct
  group LCD Interface
    ./../: images.c images.h
    ./../../UILibrary/src/: LCD_Interface.cpp
    ./../../UILibrary/inc/: LCD_Interface.h
  group Std project template
    ./../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./startup/arm/: startup_stm32f4xx.s
    ./../../../Common/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../../Common/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c misc.c
    ./../../../Common/Libraries/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/STM32F4XX_DUAL/: STM32F4xx_dual.c STM32F4xx_dual_lcd.c
    ../../../Common/Libraries/STM32_EVAL/STM32446E_EVAL/: stm32446e_eval.c stm32446e_eval_ioe.c stm32446e_eval_lcd.c
    ./../../../Common/Libraries/STM32_EVAL/: stm32_eval.c
  group STMFC
    ./../../UILibrary/STMFC/: CSTMInput.cpp CSTMInput.h CSTMLCDMngr.cpp CSTMLCDMngr.h CSTMWin.cpp CSTMWin.h CSTMWinCtrls.cpp CSTMWinCtrls.h CSTMWinForm.cpp CSTMWinForm.h font2.c font2.h STMFC.h
  group UILibrary
    ./../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group user
    ./../: main.c
    ./: LCD_MDK_asm.s
target STM324xG-EVAL (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG-EVAL +hex
  AfterMake: .\STM324xG-EVAL.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_STM324xG_EVAL
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;.\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM3240_41_G_EVAL;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC"
  memory RVCT4: ROM 0x80f0000 size 0x10000
  memory RVCT9: RAM 0x2001e000 size 0x1ff0
  memory RVCT10: RAM 0x2001fff0 size 0x10
  scatter file: .\sct\STM32F4xx.sct
target STEVAL-IHM039V1_DUALDRIVE (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STEVAL-IHM039V1_DUALDRIVE +hex
  AfterMake: .\STEVAL-IHM039V1_DUALDRIVE.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_STM32F4XX_DUAL
  c include: .\..\;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F4xx\Include;.\..\..\..\Common\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Common\Libraries\STM32_EVAL;.\..\..\..\Common\Libraries\STM32_EVAL\Common;.\..\..\..\Common\Libraries\STM32_EVAL\STM32F4xx_dual;".\..\..\MCLibrary\interface\common";".\..\..\MCApplication\interface";".\..\..\SystemDriveParams";".\..\..\UILibrary\inc";".\..\..\UILibrary\interface";".\..\..\UILibrary\STMFC"
  memory RVCT4: ROM 0x80f0000 size 0x10000
  memory RVCT9: RAM 0x2001e000 size 0x1ff0
  memory RVCT10: RAM 0x2001fff0 size 0x10
  scatter file: .\sct\STM32F4xx.sct
target STEVAL-IHM039V1_SINGLEDRIVE (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: STEVAL-IHM039V1_SINGLEDRIVE +hex
  AfterMake: .\STEVAL-IHM039V1_SINGLEDRIVE.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_STM32F4XX_DUAL
  c include: as above
  memory RVCT4: ROM 0x80f0000 size 0x10000
  memory RVCT9: RAM 0x2001e000 size 0x1ff0
  memory RVCT10: RAM 0x2001fff0 size 0x10
  scatter file: .\sct\STM32F4xx.sct
