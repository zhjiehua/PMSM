<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F10x_MC Library.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UserProject\STM32F10x_UserProjectRTOS.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>workspace_rebuild_STM3210B-EVAL</name>
      <member>
        <project>STM32F10x_MC Library</project>
        <configuration>STM32F10x_SINGLE_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F10x_UserProjectRTOS</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>workspace_rebuild_STM3210E-EVAL</name>
      <member>
        <project>STM32F10x_MC Library</project>
        <configuration>STM32F10x_SINGLE_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F10x_UserProjectRTOS</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>workspace_rebuild_STEVAL-IHM022V1_DUAL</name>
      <member>
        <project>STM32F10x_MC Library</project>
        <configuration>STM32F10x_DUAL_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F10x_UserProjectRTOS</project>
        <configuration>STEVAL-IHM022V1_DUALDRIVE</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>workspace_rebuild_STEVAL-IHM022V1_SINGLE</name>
      <member>
        <project>STM32F10x_MC Library</project>
        <configuration>STM32F10x_SINGLE_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F10x_UserProjectRTOS</project>
        <configuration>STEVAL-IHM022V1_SINGLEDRIVE</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


